options:
  parameters:
    author: LaurayLuis
    copyright: UIS
    generate_options: qt_gui
    id: Transmisor
    output_language: python
    title: Transmisor
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: 100u
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: 100u
    stop: '1'
    value: 100m
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: 100u
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50M
    step: 1M
    stop: 2.2G
    value: 50M
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: EnvolventecomplejaSSB_0
  id: EnvolventecomplejaSSB
  parameters:
    Ac: 100m
    k: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: A
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventecomplejaSSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaSSB_0, '0']

metadata:
  file_format: 1
