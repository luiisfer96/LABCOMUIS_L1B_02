options:
  parameters:
    author: Sofìa y Luis
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulaciòn PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '0.2'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 130e6
    step: '100000'
    stop: 2.2e9
    value: 130e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente portadora
    start: '0'
    step: '1e-3'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: envolventecompleja_0
  id: envolventecompleja
  parameters:
    Ac: Ac
    kp: kp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', envolventecompleja_0, '0']
- [blocks_complex_to_float_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [envolventecompleja_0, '0', blocks_complex_to_float_0, '0']
- [envolventecompleja_0, '0', qtgui_freq_sink_x_0, '0']
- [envolventecompleja_0, '0', qtgui_time_sink_x_0, '0']
- [envolventecompleja_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
